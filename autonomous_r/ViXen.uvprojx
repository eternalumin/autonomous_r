# Keil uVision project ViXen.uvprojx, settings and files
target TM4C123 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C1230H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ViXen
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Libraries&Drivers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c
  group Head
    ./Libraries&Drivers/: head.c head.h head.s
  group Neck
    ./Libraries&Drivers/: neck.c neck.h
  group Limbs
    ./Libraries&Drivers/: limbs.c limbs.h limbs.s
  group Tail
    ./Libraries&Drivers/: tail.h tail.s
  group Lights
    ./Libraries&Drivers/: lights.h lights.s
  group Timing
    ./Libraries&Drivers/: delay.c delay.h
  group Behavior
    ./Libraries&Drivers/: play_around.c play_around.h
  group Docs
    ./Libraries&Drivers/: pin_connections.txt
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
